# Keil uVision project STC8_USB.uvproj, settings and files
target STC8_USB (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: STC8_USB +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User\Inc;.\Drivers\Inc;.\USB\Inc
  link misc: ru
  group Application/User
    ./User/Src/: main.c delay.c
  group Drivers/STC8
    ./Drivers/Src/: stc8f_gpio.c
  group USB
    ./USB/Src/: usb_rx.asm usb_tx.asm usb.c usb_it.c usb_ack.asm usb_nack.asm usb_config.c usb_exit_process.asm
